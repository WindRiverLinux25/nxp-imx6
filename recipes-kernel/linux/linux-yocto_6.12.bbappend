require linux-yocto-nxp-imx6.inc

KBRANCH:nxp-imx6  = "v6.12/standard/nxp-sdk-6.12/nxp-soc"
