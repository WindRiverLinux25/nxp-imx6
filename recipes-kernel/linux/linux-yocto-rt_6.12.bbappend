require linux-yocto-nxp-imx6.inc

KBRANCH:nxp-imx6  = "v6.12/standard/preempt-rt/nxp-sdk-6.12/nxp-soc"
